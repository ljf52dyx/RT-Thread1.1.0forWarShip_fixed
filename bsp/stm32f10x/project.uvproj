# Keil uVision project project.uvproj, settings and files
target rtthread-stm32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 wLevel=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .;..\..\components\CMSIS\Include;..\..\components\finsh;..\..\components\rtgui\common;..\..\components\rtgui\include;..\..\components\rtgui\server;..\..\components\rtgui\widgets;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\MyLcd;..\..\examples\gui
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Startup
    ./: application.c startup.c board.c stm32f10x_it.c rtc.c usart.c serial.c led.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group RTGUI
    ../../components/rtgui/common/: blit.c color.c calibration.c region.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c rtgui_app.c dc.c dc_hw.c dc_buffer.c dc_client.c filerw.c image.c image_xpm.c image_hdc.c image_bmp.c image_png.c image_jpg.c image_container.c font.c font_bmp.c font_hz_file.c font_hz_bmp.c asc12font.c asc16font.c hz12font.c hz16font.c framebuffer_driver.c pixel_driver.c rtgui_mv_model.c
    ../../components/rtgui/server/: driver.c mouse.c server.c topwin.c
    ../../components/rtgui/widgets/: box.c button.c checkbox.c combobox.c iconbox.c label.c textview.c listctrl.c menu.c progressbar.c radiobox.c slider.c scrollbar.c staticline.c textbox.c listbox.c title.c notebook.c container.c list_view.c filelist_view.c widget.c window.c panel.c groupbox.c edit.c mv_view.c plot.c plot_curve.c digtube.c digfont.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group gui_examples
    ../../examples/gui/: demo_application.c demo_view.c demo_xml.c demo_view_benchmark.c demo_view_dc.c demo_view_ttf.c demo_view_dc_buffer.c demo_view_animation.c demo_view_buffer_animation.c demo_view_instrument_panel.c demo_view_window.c demo_view_label.c demo_view_button.c demo_view_checkbox.c demo_view_progressbar.c demo_view_scrollbar.c demo_view_radiobox.c demo_view_textbox.c demo_view_listbox.c demo_view_menu.c demo_view_listctrl.c demo_view_combobox.c demo_view_slider.c demo_view_notebook.c demo_view_mywidget.c demo_view_box.c demo_view_edit.c demo_view_bmp.c demo_plot.c mywidget.c demo_view_digtube.c
  group MyLCD
    ../../MyLcd/: 24cxx.c delay.c myiic.c mylcd.c mytouch.c
